/*========================================================
    FILE: mlp_model.c
========================================================*/

#include "mlp_model.h"

/*========================================================
    SCALER
========================================================*/

static const float scaler_mean[3] =
{
    28.34400000f,
    26.46825000f,
    66.99066071f
};

static const float scaler_std[3] =
{
    13.96411368f,
    5.97336826f,
    16.15513883f
};

/*========================================================
    LAYER 0 WEIGHTS
    Shape: (3 x 16)
========================================================*/

static const float W1[3][16] =
{
    {
        -0.08858263f,  0.46561918f,  0.32206632f,  0.07348907f,
        -0.43138690f, -0.44290296f, -0.55643477f,  0.47039599f,
         0.17422125f,  0.18217350f, -0.59089284f,  0.58660707f,
         0.43103713f, -0.26299329f, -0.30578426f, -0.41149010f
    },

    {
        -0.27890874f,  0.07276949f, -0.13426359f, -0.21919597f,
         0.18802217f, -0.34512496f, -0.16559606f, -0.20992244f,
        -0.10848399f,  0.37385548f, -0.27758255f, -0.04982812f,
         0.03908193f, -0.56963752f,  0.07477983f, -0.31133997f
    },

    {
        -0.43105424f,  0.50072489f,  0.56639732f,  0.32379951f,
        -0.23580687f, -0.49151303f,  0.15364593f, -0.02086481f,
        -0.37168628f, -0.05066844f, -0.47256139f,  0.43093688f,
        -0.21950506f,  0.21691183f, -0.17013028f, -0.02994552f
    }
};

/*========================================================
    LAYER 0 BIAS
========================================================*/

static const float B1[16] =
{
     0.00210071f,
    -0.29874355f,
     0.47022149f,
     0.33571856f,
     0.43735652f,
     0.49809610f,
     0.16734374f,
     0.41590728f,
    -0.51605515f,
    -0.29026466f,
    -0.47066055f,
    -0.24698282f,
    -0.17590134f,
    -0.30890052f,
     0.31922303f,
    -0.10677766f
};

/*========================================================
    LAYER 1 WEIGHTS
    Shape: (16 x 8)
========================================================*/

static const float W2[16][8] =
{
    {-0.17425438f,  0.04778523f, -0.38605906f,  0.33201462f, -0.39666399f,  0.45785683f,  0.24974683f, -0.26390833f},
    {-0.54676734f,  0.36379230f,  0.25722011f,  0.17791697f,  0.21728694f, -0.37459442f, -0.08674406f, -0.43424320f},
    { 0.29998610f,  0.13607445f, -0.11225560f, -0.48671047f, -0.21667744f, -0.12081432f,  0.28712740f,  0.07606895f},
    { 0.32663981f,  0.01326560f, -0.32614200f,  0.17280035f,  0.20650590f,  0.11250231f,  0.32276696f, -0.06225380f},
    { 0.07601743f, -0.12537572f, -0.52776430f, -0.33778132f, -0.41337597f,  0.08197617f, -0.24305217f,  0.06107169f},
    { 0.45530132f, -0.29552540f, -0.13723875f,  0.30661751f, -0.21644760f, -0.47282863f, -0.26636241f, -0.29122243f},
    { 0.49057124f,  0.25190867f,  0.07859770f,  0.43066307f,  0.35899525f, -0.36765080f,  0.33067333f,  0.09638678f},
    { 0.23758861f,  0.45944555f, -0.11625816f, -0.45540781f, -0.33800822f, -0.00661834f,  0.38347523f,  0.29055580f},
    {-0.45058639f,  0.06787266f, -0.02991086f, -0.33828380f, -0.43420829f, -0.10558419f,  0.50356244f, -0.23220273f},
    { 0.03661161f,  0.23177671f, -0.10862447f,  0.43016531f,  0.42701861f, -0.21314676f,  0.01882213f, -0.22213136f},
    {-0.15261668f, -0.42035356f,  0.05813816f,  0.03582371f, -0.45589532f, -0.26457969f,  0.41285807f, -0.20386682f},
    {-0.41086789f,  0.04213407f,  0.53956762f, -0.31190804f,  0.11514476f,  0.31602669f, -0.20448457f,  0.17501464f},
    {-0.19527215f,  0.19103572f,  0.19007841f, -0.02530275f, -0.46574499f,  0.39187372f, -0.11645634f, -0.37331936f},
    {-0.50135671f,  0.14725804f,  0.23561648f, -0.53850376f, -0.04626099f, -0.21068103f,  0.20364892f, -0.37969006f},
    { 0.24196620f, -0.16430921f,  0.38555898f, -0.30991003f, -0.10525059f, -0.43924940f,  0.36922766f,  0.42817541f},
    {-0.19108081f,  0.20023235f,  0.27786672f,  0.03542559f,  0.00321769f, -0.27012719f, -0.36739102f,  0.39410663f}
};

/*========================================================
    LAYER 1 BIAS
========================================================*/

static const float B2[8] =
{
     0.40546441f,
     0.08368816f,
    -0.20616795f,
    -0.09772589f,
     0.27776900f,
     0.34534845f,
     0.33199042f,
     0.32486840f
};

/*========================================================
    LAYER 2 WEIGHTS
========================================================*/

static const float W3[8] =
{
     0.28429863f,
    -0.73805533f,
    -0.60721460f,
     0.66011058f,
     0.13975055f,
    -0.81294079f,
    -0.61093712f,
     0.32238011f
};

/*========================================================
    LAYER 2 BIAS
========================================================*/

static const float B3 =
    -0.75731160f;

/*========================================================
    TANH ACTIVATION
========================================================*/

static float activate_tanh(float x)
{
    return tanhf(x);
}

/*========================================================
    MLP PREDICT - 3 LAYER
========================================================*/

float mlp_predict(float soil,
                  float temp,
                  float hum)
{
    float input[3];

    float hidden1[16];
    float hidden2[8];

    float output;

    /*====================================================
        NORMALIZE
    ====================================================*/

    input[0] = (soil - scaler_mean[0]) / scaler_std[0];
    input[1] = (temp - scaler_mean[1]) / scaler_std[1];
    input[2] = (hum  - scaler_mean[2]) / scaler_std[2];

    /*====================================================
        HIDDEN LAYER 1
    ====================================================*/

    for(int j = 0; j < 16; j++)
    {
        float sum = B1[j];

        for(int i = 0; i < 3; i++)
        {
            sum += input[i] * W1[i][j];
        }

        hidden1[j] = activate_tanh(sum);
    }

    /*====================================================
        HIDDEN LAYER 2
    ====================================================*/

    for(int j = 0; j < 8; j++)
    {
        float sum = B2[j];

        for(int i = 0; i < 16; i++)
        {
            sum += hidden1[i] * W2[i][j];
        }

        hidden2[j] = activate_tanh(sum);
    }

    /*====================================================
        OUTPUT LAYER
    ====================================================*/

    output = B3;

    for(int i = 0; i < 8; i++)
    {
        output += hidden2[i] * W3[i];
    }

    output = activate_tanh(output);

    return output;
}

/*========================================================
    CLASSIFICATION
========================================================*/

uint8_t mlp_classify(float soil,
                     float temp,
                     float hum)
{
    float y = mlp_predict(soil, temp, hum);

    if(y > 0.0f)
    {
        return 1;
    }
    else
    {
        return 0;
    }
}
